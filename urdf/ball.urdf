Commit message: patch URDF + PhysX

File: urdf/ball.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link sphere: geometry collision sphere radius=0.02; visual sphere radius=0.02
